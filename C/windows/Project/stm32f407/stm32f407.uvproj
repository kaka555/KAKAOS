# Keil uVision project stm32f407.uvproj, settings and files
target KAKAOS (ARM-GNU)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f407
  group CMSIS
    ../../source/src/kernel/OS_CPU/stm32f407/CMSIS/: system_stm32f4xx.c
    ../../source/src/kernel/OS_CPU/stm32f407/CMSIS/startup/: startup_stm32f40_41xxx.s
  group OS_CORE
    ../../source/src/kernel/OS_CORE/: bsp.c osinit.c
    ../../source/src/kernel/OS_CORE/dmodule/: export.c module.c
    ../../source/src/kernel/OS_CORE/fs/: device.c vfs.c vfs_default_fun.c vfsio.c
    ../../source/src/kernel/OS_CORE/ipc/: MCB.c message_queue.c mutex.c
    ../../source/src/kernel/OS_CORE/schedule/: os_delay.c os_ready.c os_schedule.c os_suspend.c os_TCB_list.c os_tick.c TCB.c
    ../../source/src/kernel/OS_CORE/time/: os_time.c os_timer.c
  group OS_CPU
    ../../source/src/kernel/OS_CPU/stm32f407/: CPU_A.s OS_CPU_A.s OS_CPU_STM32.c stm32f4xx_it.c
    ../../source/src/kernel/OS_CPU/stm32f407/bsp/: stm32_bsp.c usart.c sys.c
  group OS_LIB
    ../../source/src/kernel/OS_LIB/: buddy.c heap_oo.c insert_sort_oo.c malloc.c myassert.c myMicroLIB.c singly_linked_list.c slab.c vector.c
  group SHELL
    ../../source/src/kernel/SHELL/: command_processor.c shell.c shell_debug.c shell_fun.c
  group USER
    ../../source/user/: user.c
  group FWlib
    ../../source/src/kernel/OS_CPU/stm32f407/FWlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
