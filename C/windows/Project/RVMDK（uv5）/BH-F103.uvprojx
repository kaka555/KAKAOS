# Keil uVision project BH-F103.uvprojx, settings and files
target KAKAOS (ARM-GNU)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103
  group include
    ../../source/include/: user.h
    ../../source/include/os_base/: ka_configuration.h os_error.h printf_debug.h barrier.h
    ../../source/include/os_core/: task_state.h TCB.h MCB.h os_time.h os_timer.h message_queue.h mutex.h
    ../../source/include/os_core/schedule/: os_delay.h os_ready.h os_schedule.h os_suspend.h os_TCB_list.h
    ../../source/include/os_cpu/: os_cpu.h os_cpu_stm32.h
    ../../source/include/os_cpu/bsp/: bsp_usart.h sram.h
    ../../source/include/os_lib/: buddy.h double_linked_list.h heap_oo.h insert_sort_oo.h myMicroLIB.h slab.h vector.h singly_linked_list.h
    ../../source/include/shell/: command_processor.h shell.h shell_debug.h shell_fun.h
  group CMSIS
    ../../source/src/CMSIS/: core_cm3.c system_stm32f10x.c
    ../../source/src/CMSIS/startup/: startup_stm32f10x_hd.s
  group FWlib
    ../../source/src/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../source/src/FWlib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group OS_CORE
    ../../source/src/kernel/OS_CORE/: osinit.c bsp.c
    ../../source/src/kernel/OS_CORE/schedule/: os_delay.c os_ready.c os_schedule.c os_suspend.c os_TCB_list.c os_tick.c TCB.c
    ../../source/src/kernel/OS_CORE/dmodule/: export.c module.c
    ../../source/src/kernel/OS_CORE/ipc/: MCB.c message_queue.c mutex.c
    ../../source/src/kernel/OS_CORE/time/: os_time.c os_timer.c
    ../../source/src/kernel/OS_CORE/fs/: vfs.c vfsio.c vfs_default_fun.c device.c
  group OS_CPU
    ../../source/src/kernel/OS_CPU/: CPU_A.s OS_CPU_A.s OS_CPU_STM32.c stm32f10x_it.c
    ../../source/src/kernel/OS_CPU/bsp/: bsp_usart.c sram.c stm32_bsp.c
  group OS_LIB
    ../../source/src/kernel/OS_LIB/: buddy.c heap_oo.c insert_sort_oo.c malloc.c myassert.c myMicroLIB.c singly_linked_list.c slab.c vector.c
  group shell
    ../../source/src/kernel/SHELL/: command_processor.c shell.c shell_debug.c shell_fun.c
  group user
    ../../source/user/: bsp_led.c user.c
